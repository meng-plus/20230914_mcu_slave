<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\20230914_mcu_slave.ewp</path>
  </project>
  <batchBuild />
</workspace>
