# IAR project 20230914_mcu_slave.ewp, settings and files
configuration 20230914_mcu_slave (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\Application\efsm\task_0; ..\Application\efsm; ..\Third_party\utils\list
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 20230914_mcu_slave.hex
  ILINK.IlinkOutputFile: 20230914_mcu_slave.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Application/: task_1ms.c
  group Application/efsm
    ../Application/efsm/: efsm.c efsm.h efsm_node_idle.c efsm_node_warning.c
  group Application/efsm/task0
    ../Application/efsm/task_0/: efsm_node_0_A.c efsm_node_0_BD.c efsm_node_0_C.c efsm_node_0_E.c efsm_task_0.c
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: adc.c gpio.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c
  group build
    ./: stm32f103xb_flash.icf
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group ThirdParty/utils/list
    ../Third_party/utils/list/: list.c slist.c
